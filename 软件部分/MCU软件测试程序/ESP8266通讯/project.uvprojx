# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: first project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Start;.\Library;.\User;.\Hardware;.\System\delay;.\System\sys;.\System\usart;.\Hardware\TIM;.\Hardware\KEY;.\Hardware\RGB_LIGHT;.\Hardware\LCD;.\Hardware\SPI;.\Hardware\W25QXX;.\Hardware\MENU;.\Hardware\Encoder;.\Hardware\STORAGE;.\Hardware\ESP8266WiFi
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: system_stm32f10x.h core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group Hardware
    ./Hardware/TIM/: TIM.c
    ./Hardware/KEY/: KEY.c
    ./Hardware/RGB_LIGHT/: RGB_LIGHT.c
    ./Hardware/LCD/: oled.c
    ./Hardware/MENU/: Menu.c
    ./Hardware/SPI/: spi.c
    ./Hardware/W25QXX/: w25q64.c
    ./Hardware/Encoder/: Encoder.c
    ./Hardware/STORAGE/: Storage.c
    ./Hardware/ESP8266WiFi/: ESP8266WiFi.c
  group System
    ./System/delay/: delay.c delay.h
    ./System/sys/: sys.c sys.h
    ./System/usart/: usart.c usart.h
  group Header
    ./Hardware/RGB_LIGHT/: RGB_ColorNUMs.h RGB_LIGHT.h
    ./Hardware/LCD/: oled.h
    ./Hardware/MENU/: Menu.h
    ./Hardware/W25QXX/: w25qxx.h
    ./Hardware/STORAGE/: Storage.h
    ./Hardware/ESP8266WiFi/: ESP8266WiFi.h
